# Keil uVision project ElevatorSche.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ElevatorSche +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c main.c
    E:/OneDrive/OneDrive - whu.edu.cn/Desktop/程序源码/KeilProject/5-2 LCD1602调试工具/: LCD1602.c
